# IAR project STSPIN32F0.ewp, settings and files
configuration STSPIN32F0A_ESC (ARM, debug)
  General.OGChipSelectEditMenu: STM32F031C6 ST STM32F031C6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STEVAL_ESC002V1; USE_HAL_DRIVER; STM32F031x6; UART_COMM; SENSE_COMPARATORS; ARR_FILTER; NO_OPEN_LOOP_RAMP; NO_VARIABLE_ADVANCE; FAST_DEMAG; PID_V2; OPEN_LOOP; MC_7PP_3S_PROPELLER; DELTA_6STEP_TABLE; COMPLEMENTARY_DRIVE; VOLTAGE_MODE; NO_SPEED_SENDING; NO_SPEED_RAMP
  ICCARM.CCIncludePath2: Inc; Middlewares\ST\MC_6Step_Lib\Inc; Middlewares\ST\UART_serial_com\Inc; Drivers\BSP\STEVAL-ESC002V1; Drivers\BSP\Components\stspin32f0; Drivers\BSP\Components\Common; Drivers\CMSIS\Device\ST\STM32F0xx\Include; Drivers\CMSIS\Include; Drivers\STM32F0xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EWARM_STSPIN32F0A_ESC.bin
  ILINK.IlinkOutputFile: STSPIN32F0.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    Src/: exti.c main_32F0.c spi.c stspin32f0_hal_msp.c stspin32f0_it.c
    Inc/: main_32F0.h MC_SixStep_param_2036_U_024_B_K312.h MC_SixStep_param_32F0.h MC_SixStep_param_7PP_3S_propeller.h stm32f0xx_hal_conf.h stspin32f0_it.h
    Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f031x6.s
    Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/BSP/Components
    Drivers/BSP/Components/stspin32f0/: stspin32f0.c stspin32f0.h
  group Drivers/BSP/STEVAL-ESC002V1
    Drivers/BSP/STEVAL-ESC002V1/: STEVAL-ESC002V1.c STEVAL-ESC002V1.h
  group Drivers/STM32F0xx_HAL_Driver
    Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_cec.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_exti.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_irda.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_smartcard.c stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_smbus.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_wwdg.c stm32f0xx_ll_adc.c stm32f0xx_ll_comp.c stm32f0xx_ll_crc.c stm32f0xx_ll_crs.c stm32f0xx_ll_dac.c stm32f0xx_ll_dma.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_i2c.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_rtc.c stm32f0xx_ll_spi.c stm32f0xx_ll_tim.c stm32f0xx_ll_usart.c stm32f0xx_ll_utils.c
  group Middlewares/MC_6Step_Lib
    Middlewares/ST/MC_6Step_Lib/Src/: 6Step_Lib.c
  group Middlewares/UART_serial_com
    Middlewares/ST/UART_serial_com/Src/: UART_UI.c
